## Kconfig
```kconfig
config VGLITE
    bool "Enable vglite library"
    default n
    select THREAD_LOCAL_STORAGE
```
